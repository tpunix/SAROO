# Keil uVision project ssmaster.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ssmaster
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1
  c define: STM32F10X_HD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group StartUp
    ./: startup_stm32f10x_hd.s main.c printk.c uart.c shell.c RTX_Conf_CM.c
  group SDCARD
    ./: stm32_sdio.c
    ./fatfs/: diskio.c ff.c file_utils.c ffunicode.c
  group FPGA
    ./fpga_config/: spi.c
  group Saturn
    ./saturn/: saturn_main.c saturn_cdc.c cdda_i2s.c cdimg.c
